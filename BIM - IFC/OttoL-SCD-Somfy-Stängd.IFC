Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: OttoL-SCD-Somfy-Stängd.IFC
Time: 2025-01-13T08:30:23
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10398_Otto L
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10406_OttoL
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10408-1
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 10408-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10408-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10408-4
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20028_7982---*6-13-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20075_7982---*6-13-mattssons (10)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20129_7982--*14-19-mattssons (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30211_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 6060-F22 (Hydro)

# IfcBuildingElementProxy: 30212_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30213_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30221_100cm Otto Becker
In: Default Storey
PredefinedType: ELEMENT; Material: Galvanized Steel

# IfcBuildingElementProxy: 30234_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30235_SCD-Somfy
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30236_4cm (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 33322___6_20-mattssons (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40136_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40137
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40138
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40139 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40144
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40145
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40146
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40147
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40153-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40153-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40674
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40675
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40676 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40677 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40679 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40698_Otto
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40700
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40734
In: Default Storey
PredefinedType: ELEMENT; Material: DC01+ZE

# IfcBuildingElementProxy: 90044 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Cut-Extrude1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: FTS FZB ST3,9X9,5.step (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: ISO 4762 M4 x 16_09122 4 16-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Otto L-SCD-Väv_Uppe-Somfy
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Sweep4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: din7996_5x45_st_z (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: hex flange nut gradea_iso_ISO - 4161 - M6 - N (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: hexa csunk raisedhd screw tapping_iso_ISO 14587 ST3.5x16-Type R-N (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: pan head cross recess screw_iso_ISO 7045 - M4 x 20 - Z - 20N
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: plain washer 10669 type nl_iso_ISO 10669-5.4-N (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
