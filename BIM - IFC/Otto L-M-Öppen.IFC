Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Otto L-M-Öppen.IFC
Time: 2025-01-13T08:00:24
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10024
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10049
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 10049-2
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 20028_7982---*6-13-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20032_M6 Flänsmutter (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20049 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 20075_7982---*6-13-mattssons (10)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20129_7982--*14-19-mattssons (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30112_Otto L
In: Default Storey
PredefinedType: ELEMENT; Material: DC01+ZE

# IfcBuildingElementProxy: 30211_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 6060-F22 (Hydro)

# IfcBuildingElementProxy: 30212_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30213_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30234_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30235_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30236_4cm (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 33322___6_20-mattssons (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40136_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40137
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40138
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40140 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40144
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40145
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40146
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40147
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40153-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40153-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40674
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40675
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40676 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40677 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40679 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40698_Otto
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40700
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: CS TX ST3.5 x 16_79834B -6 16-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: ISO 4762 M4 x 16_09122 4 16-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Otto L-M-Väv_Nere-Becker
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Träskruv (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
